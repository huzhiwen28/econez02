# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\uCOS-II\uC-CPU;..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\app;..\..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\User\bsp\RVMDK\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ../../User/app/: app.c app_cfg.h includes.h os_cfg.h app_kernelregs.c app_kernelregs.h app_backend.c app_usbcom.c app_usbgather.c app_usbmodbusmaster.c app_usbmodbusslave.c app_backend.h app_usbcom.h app_usbgather.h app_usbmodbusmaster.h app_usbmodbusslave.h app_485modbusslave.c app_485com.c app_485modbusslave.h app_485com.h app_basicdef.c app_OutControl.c app_pid.c app_action.c app_inout.c app_Port.c app_PidOut.c app_Port.h app_PidOut.h app_encryption.c app_encryption.h
  group BSP
    ../../User/bsp/: bsp.c bsp_usart.c stm32f10x_conf.h bsp_led.c bsp_button.c bsp_int.c bsp_232c.c bsp_fifo.c bsp_fifo.h bsp_232c.h bsp_485.c bsp_485.h usb_pwr.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c bsp_usb.c bsp_usb.h bsp_eeprom.h bsp_eeprom.c stm32f10x_encoder.h bsp_dac.h bsp_enc.h bsp_GPIO.h bsp_sonic.h bsp_TimesInt.h stm32f10x_encoder.c bsp_adc.c bsp_dac.c bsp_enc.c bsp_GPIO.c bsp_sonic.c bsp_TimesInt.c bsp_extsram.c bsp_extsram.h
  group RVMDK
    ../../User/bsp/RVMDK/: init.s vectors.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_fsmc.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h stm32f10x.h
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group uCOS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-II/uC-CPU/: cpu_def.h
  group Scatter
    ../../User/bsp/RVMDK/: STM32_Flash.scat
  group usb
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
